# Keil uVision project dfu.uvproj, settings and files
target dfu (ARM-ADS)
  device: GD32F107VC GigaDevice
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x08000000-0x0803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: dfu +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,GD32F10X_CL
  c misc: --c99
  c include: ..\inc;..\..\..\..\..\Firmware\CMSIS\GD\GD32F10x\Include;..\..\..\..\..\Firmware\GD32F10x_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32F10x_usbfs_library\driver\Include;..\..\..\..\..\Firmware\GD32F10x_usbfs_library\device\core\Include;..\..\..\..\..\Firmware\GD32F10x_usbfs_library\device\class\dfu\Include;..\..\..\..\..\Firmware\GD32F10x_usbfs_library\ustd\common;..\..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../src/: app.c gd32f10x_hw.c gd32f10x_it.c exmc_nandflash.c gd25qxx.c inter_flash_if.c nand_flash_if.c nor_flash_if.c
  group CMSIS
    ../src/: system_gd32f10x.c
  group GD32F10x_Peripherals
    ../../../../../Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_spi.c gd32f10x_exmc.c
  group GD32F10x_EVAL
    ../../../../../Utilities/: gd32f10x_eval.c
  group USB_Drivers
    ../../../../../Firmware/GD32F10x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../../../../../Firmware/GD32F10x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../../../../../Firmware/GD32F10x_usbfs_library/device/class/dfu/Source/: dfu_core.c dfu_mem.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_cl.s
  group Doc
    ../: readme.txt
